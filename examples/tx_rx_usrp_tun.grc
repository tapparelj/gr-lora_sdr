options:
  parameters:
    author: Justin Garey & Zach Naymik
    generate_options: no_gui
    id: tx_rx_usrp_tun
    output_language: python
  states: {}

blocks:
- name: Att_dB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: bw
  id: variable
  parameters:
    comment: Bandwidth
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: cr
  id: variable
  parameters:
    comment: |-
      Coding
      Rate
    value: '2'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: |-
      Spreading 
      Factor
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**((Att_dB)/20)
    minoutbuf: '10000000'
    type: complex
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'False'
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_frame_info_to_pdu_0
  id: lora_sdr_frame_info_to_pdu
  parameters: {}
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate_rx/bw)
    preamb_len: '8'
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'False'
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: '0'
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '2'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate_tx/bw)
    minoutbuf: '10000000'
    preamb_len: '8'
    samp_rate: samp_rate_tx
    sf: sf
    sync_words: '0x12'
  states: {}
- name: lora_sdr_pdu_to_whitening_msg_0
  id: lora_sdr_pdu_to_whitening_msg
  parameters:
    comment: Converts TUN PDUs to whitening message input
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: network_tuntap_pdu_0
  id: network_tuntap_pdu
  parameters:
    ifn: lora-tun0
    istunflag: 'True'
    mtu: '1500'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: ''
    gain0: '10'
    len_tag_name: frame_len
    samp_rate: samp_rate_tx
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bw
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: ''
    gain0: '20'
    minoutbuf: 2**sf<<2
    samp_rate: samp_rate_rx
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, '0', lora_sdr_frame_info_to_pdu_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_info_to_pdu_0, pdus, network_tuntap_pdu_0, pdus]
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_multiply_const_vxx_0, '0']
- [lora_sdr_pdu_to_whitening_msg_0, msg, lora_sdr_whitening_0, msg]
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [network_tuntap_pdu_0, pdus, lora_sdr_pdu_to_whitening_msg_0, pdus]
- [uhd_usrp_source_0_0, '0', lora_sdr_frame_sync_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
