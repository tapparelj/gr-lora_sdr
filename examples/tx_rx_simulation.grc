options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL
    gen_cmake: 'Off'
    generate_options: no_gui
    id: tx_rx_simulation
    output_language: python
  states: {}

blocks:
- name: SNRdB
  id: variable
  parameters:
    value: '-5'
  states: {}
- name: bw
  id: variable
  parameters:
    comment: Bandwidth
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: clk_offset
  id: variable
  parameters:
    comment: Clock offset in ppm
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    comment: |-
      Coding
      Rate
    value: '2'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: ldro
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: |-
      Spreading 
      Factor
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/yujwu/Documents/gr-lora_sdr/python/lora_sdr/qa_ref/temp/ref_flow_mod.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/yujwu/Documents/gr-lora_sdr/python/lora_sdr/qa_ref/temp/ref_fft_demod_input.bin
    type: short
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/yujwu/Documents/gr-lora_sdr/python/lora_sdr/qa_ref/temp/ref_flow_patt.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/yujwu/Documents/gr-lora_sdr/python/lora_sdr/qa_ref/qa_ref_flow_mod/ref_flow_mod_sf7_cr2.bin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/yujwu/Documents/gr-lora_sdr/python/lora_sdr/qa_ref/qa_ref_tx_no_mod/ref_tx_sf7_cr2.bin
    repeat: 'False'
    type: int
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: '"/home/yujwu/Documents/gr-lora_sdr/data/GRC_default/example_tx_source.txt"'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/yujwu/Documents/gr-lora_sdr/python/lora_sdr/qa_ref/temp/ref_fft_demod_input.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_patterned_interleaver_0
  id: blocks_patterned_interleaver
  parameters:
    pattern: '[0]*50000+[1]*50000'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {state: disabled}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_vector_sink_x_1
  id: blocks_vector_sink_x
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_vector_sink_x_2
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: 1.0+clk_offset*1e-6
    freq_offset: center_freq*clk_offset*1e-6/samp_rate
    minoutbuf: int(2**sf*samp_rate/bw*1.1)
    noise_voltage: 10**(-SNRdB/20)
    seed: '0'
    taps: 1.0 + 0.0j
  states: {state: disabled}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: 'True'
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'False'
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {state: disabled}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {state: disabled}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {state: disabled}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {state: disabled}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: ldro
    pay_len: pay_len
    print_header: 'True'
  states: {state: disabled}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: ldro
    sf: sf
  states: {state: disabled}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    preamb_len: preamb_len
    samp_rate: samp_rate
    sf: sf
    sync_words: '0x12'
  states: {state: disabled}
- name: lora_sdr_modulate_1
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '0x12'
  states: {state: disabled}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: file_source
    use_length_tag: 'False'
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_patterned_interleaver_0, '0']
- [blocks_file_source_0, '0', lora_sdr_modulate_1, '0']
- [blocks_file_source_0_0, '0', lora_sdr_whitening_0, '0']
- [blocks_file_source_0_1, '0', lora_sdr_fft_demod_0, '0']
- [blocks_patterned_interleaver_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_patterned_interleaver_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', lora_sdr_frame_sync_0, '0']
- [blocks_throttle_0_0, '0', blocks_file_sink_1, '0']
- [blocks_vector_source_x_0, '0', lora_sdr_add_crc_0, '0']
- [channels_channel_model_0, '0', lora_sdr_frame_sync_0, '0']
- [lora_sdr_add_crc_0, '0', blocks_vector_sink_x_2, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', blocks_file_sink_0_0, '0']
- [lora_sdr_fft_demod_0, '0', blocks_vector_sink_x_1, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', blocks_patterned_interleaver_0, '1']
- [lora_sdr_modulate_0, '0', blocks_throttle_0, '0']
- [lora_sdr_modulate_0, '0', blocks_vector_sink_x_0, '0']
- [lora_sdr_modulate_1, '0', blocks_throttle_0_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
