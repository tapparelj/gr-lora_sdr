options:
  parameters:
    description: Simulation example LoRa
    generate_options: no_gui
    id: lora_sim_profiling
    output_language: python
    run_options: run
    thread_safe_setters: '1'
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: delay_sf1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_sf2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_sf3
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_sf4
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_sf5
  id: variable
  parameters:
    value: '0'
  states: {}
- name: delay_sf6
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: multi_control
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '8'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sf2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sf3
  id: variable
  parameters:
    value: '9'
  states: {}
- name: sf4
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sf5
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sf6
  id: variable
  parameters:
    value: '12'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_sf1
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_sf2
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_sf3
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_sf4
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_sf5
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0_0_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_sf6
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf2*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf3*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf4*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf5*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf6*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {}
- name: lora_sdr_hier_rx_0_0_0_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '9'
  states: {}
- name: lora_sdr_hier_rx_0_1_0_0_0_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '12'
  states: {}
- name: lora_sdr_hier_rx_0_1_0_0_0_0_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '8'
  states: {}
- name: lora_sdr_hier_rx_0_1_0_0_1
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '11'
  states: {}
- name: lora_sdr_hier_rx_0_1_0_0_1_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: lora_sdr_hier_rx_0_2_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '10'
  states: {}
- name: lora_sdr_hier_tx_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'False'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {}
- name: lora_sdr_hier_tx_0_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'False'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf2
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}
- name: lora_sdr_hier_tx_0_0_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'False'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf3
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}
- name: lora_sdr_hier_tx_0_0_0_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'False'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf4
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}
- name: lora_sdr_hier_tx_0_0_0_0_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'True'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf5
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}
- name: lora_sdr_hier_tx_0_0_0_0_0_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'True'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf6
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}
- name: lora_sdr_hier_tx_0_2
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'True'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf2
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_1, '0', blocks_throttle_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_delay_0, '0', blocks_throttle_0_0, '0']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [blocks_delay_0_0_0_0_0_0, '0', blocks_add_xx_0, '5']
- [blocks_throttle_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle_0_0, '0', interp_fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle_0_0, '0', interp_fir_filter_xxx_0_0_0_0_0, '0']
- [blocks_throttle_0_0, '0', interp_fir_filter_xxx_0_0_0_0_0_0, '0']
- [blocks_throttle_0_0, '0', interp_fir_filter_xxx_0_0_0_0_0_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', lora_sdr_hier_rx_0_1_0_0_1_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', lora_sdr_hier_rx_0_1_0_0_0_0_0, '0']
- [interp_fir_filter_xxx_0_0_0_0, '0', lora_sdr_hier_rx_0_0_0_0, '0']
- [interp_fir_filter_xxx_0_0_0_0_0, '0', lora_sdr_hier_rx_0_2_0, '0']
- [interp_fir_filter_xxx_0_0_0_0_0_0, '0', lora_sdr_hier_rx_0_1_0_0_1, '0']
- [interp_fir_filter_xxx_0_0_0_0_0_0_0, '0', lora_sdr_hier_rx_0_1_0_0_0_0, '0']
- [lora_sdr_hier_tx_0, '0', blocks_delay_0, '0']
- [lora_sdr_hier_tx_0_0, '0', blocks_delay_0_0, '0']
- [lora_sdr_hier_tx_0_0_0, '0', blocks_delay_0_0_0, '0']
- [lora_sdr_hier_tx_0_0_0_0, '0', blocks_delay_0_0_0_0, '0']
- [lora_sdr_hier_tx_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0, '0']
- [lora_sdr_hier_tx_0_0_0_0_0_0, '0', blocks_delay_0_0_0_0_0_0, '0']
- [lora_sdr_hier_tx_0_2, '0', blocks_add_xx_1, '1']

metadata:
  file_format: 1
