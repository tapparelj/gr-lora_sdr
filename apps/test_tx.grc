options:
  parameters:
    generate_options: no_gui
    id: test_tx
    output_language: python
    title: TestFile
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '8'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: sf2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sf3
  id: variable
  parameters:
    value: '9'
  states: {}
- name: sf4
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_random_0_1_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: frame_period
    msg: pmt.intern('')
    std: '5'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_regenerate_bb_0
  id: blocks_regenerate_bb
  parameters:
    max_regen: '500'
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: 1, 1
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_streams_0_0
  id: blocks_stream_to_streams
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_streams_0_1
  id: blocks_stream_to_streams
  parameters:
    num_streams: '3'
    type: complex
  states: {state: disabled}
- name: blocks_streams_to_stream_0
  id: blocks_streams_to_stream
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {state: disabled}
- name: lora_sdr_add_crc_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_add_crc_0_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_add_crc_0_0_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {state: disabled}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0_1
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_crc_verif_0_1_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_data_source_0_1_0
  id: lora_sdr_data_source
  parameters:
    n_frames: n_frame
    pay_len: pay_len
    string_input: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}
- name: lora_sdr_data_source_0_1_0_0
  id: lora_sdr_data_source
  parameters:
    n_frames: n_frame
    pay_len: pay_len
    string_input: DkzTEkJgm4nWmmhHddkGq6BUa7xfto3CdAlyRumnKgshlfxA73xvXnCIRRYefeZY
  states: {}
- name: lora_sdr_data_source_0_1_0_0_0
  id: lora_sdr_data_source
  parameters:
    n_frames: n_frame
    pay_len: pay_len
    string_input: DkzTEkJgm4nWmmhHddkGq6BUa7xfto3CdAlyRumnKgshlfxA73xvXnCIRRYefeZY
  states: {}
- name: lora_sdr_data_source_0_1_0_0_0_0
  id: lora_sdr_data_source
  parameters:
    n_frames: n_frame
    pay_len: pay_len
    string_input: DkzTEkJgm4nWmmhHddkGq6BUa7xfto3CdAlyRumnKgshlfxA73xvXnCIRRYefeZY
  states: {state: disabled}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf2
  states: {}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_deinterleaver_0_1
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf3
  states: {}
- name: lora_sdr_deinterleaver_0_1_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf4
  states: {state: disabled}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_1
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_dewhitening_0_1_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf2
  states: {}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_fft_demod_0_1
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf3
  states: {}
- name: lora_sdr_fft_demod_0_1_0
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf4
  states: {state: disabled}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf2
  states: {}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_frame_sync_0_1
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf3
  states: {}
- name: lora_sdr_frame_sync_0_1_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf4
  states: {state: disabled}
- name: lora_sdr_gray_decode_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {state: disabled}
- name: lora_sdr_gray_decode_0_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_decode_0_0_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf2
  states: {}
- name: lora_sdr_gray_decode_0_0_0_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf2
  states: {state: disabled}
- name: lora_sdr_gray_enc_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_gray_enc_0_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_gray_enc_0_1
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_gray_enc_0_1_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_1
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_1_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {state: disabled}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf2
  states: {}
- name: lora_sdr_hamming_enc_0_0_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf2
  states: {state: disabled}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {state: disabled}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_0_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_0_0_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {state: disabled}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_header_decoder_0_1
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_header_decoder_0_1_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {state: disabled}
- name: lora_sdr_hier_rx_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_sdr_hier_rx_0_1
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf2
  states: {state: disabled}
- name: lora_sdr_hier_tx_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: ''
  states: {state: disabled}
- name: lora_sdr_hier_tx_0_1
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf2
    src_data: ''
  states: {state: disabled}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {state: disabled}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_interleaver_0_0_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf2
  states: {}
- name: lora_sdr_interleaver_0_0_0_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf2
  states: {state: disabled}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_sdr_modulate_0_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_modulate_0_0_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf2
  states: {}
- name: lora_sdr_modulate_0_0_0_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf2
  states: {state: disabled}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters: {}
  states: {state: disabled}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}
- name: lora_sdr_whitening_0_0_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}
- name: lora_sdr_whitening_0_0_0_0
  id: lora_sdr_whitening
  parameters: {}
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_1_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: test
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: test
  states: {}

connections:
- [blocks_add_xx_0, '0', rational_resampler_xxx_0_1_1_0, '0']
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_data_source_0_1_0, trigg]
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_data_source_0_1_0_0, trigg]
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_data_source_0_1_0_0_0, trigg]
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_data_source_0_1_0_0_0_0, trigg]
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_hier_tx_0, trigg]
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_hier_tx_0_1, trigg]
- [blocks_multiply_xx_0, '0', blocks_stream_to_streams_0_1, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_to_streams_0, '0', lora_sdr_frame_sync_0_0, '0']
- [blocks_stream_to_streams_0, '1', lora_sdr_frame_sync_0, '0']
- [blocks_stream_to_streams_0, '2', lora_sdr_frame_sync_0_1, '0']
- [blocks_stream_to_streams_0_0, '0', lora_sdr_hier_rx_0, '0']
- [blocks_stream_to_streams_0_0, '1', lora_sdr_hier_rx_0_1, '0']
- [blocks_streams_to_stream_0, '0', blocks_stream_to_streams_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_1, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_throttle_1, '0', blocks_add_xx_0, '0']
- [blocks_throttle_1_0, '0', blocks_add_xx_0, '1']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_add_crc_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_add_crc_0_0_0, '0', lora_sdr_hamming_enc_0_0_0, '0']
- [lora_sdr_add_crc_0_0_0_0, '0', lora_sdr_hamming_enc_0_0_0_0, '0']
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_add_crc_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_header_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_interleaver_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_modulate_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_whitening_0, msg]
- [lora_sdr_data_source_0_1_0_0, msg, lora_sdr_add_crc_0_0, msg]
- [lora_sdr_data_source_0_1_0_0, msg, lora_sdr_header_0_0, msg]
- [lora_sdr_data_source_0_1_0_0, msg, lora_sdr_interleaver_0_0, msg]
- [lora_sdr_data_source_0_1_0_0, msg, lora_sdr_modulate_0_0, msg]
- [lora_sdr_data_source_0_1_0_0, msg, lora_sdr_whitening_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0, msg, lora_sdr_add_crc_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0, msg, lora_sdr_header_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0, msg, lora_sdr_interleaver_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0, msg, lora_sdr_modulate_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0, msg, lora_sdr_whitening_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0_0, msg, lora_sdr_add_crc_0_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0_0, msg, lora_sdr_header_0_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0_0, msg, lora_sdr_interleaver_0_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0_0, msg, lora_sdr_modulate_0_0_0_0, msg]
- [lora_sdr_data_source_0_1_0_0_0_0, msg, lora_sdr_whitening_0_0_0_0, msg]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_deinterleaver_0_1, '0', lora_sdr_hamming_dec_0_1, '0']
- [lora_sdr_deinterleaver_0_1_0, '0', lora_sdr_hamming_dec_0_1_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_dewhitening_0_1, '0', lora_sdr_crc_verif_0_1, '0']
- [lora_sdr_dewhitening_0_1_0, '0', lora_sdr_crc_verif_0_1_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_enc_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_enc_0_0, '0']
- [lora_sdr_fft_demod_0_1, '0', lora_sdr_gray_enc_0_1, '0']
- [lora_sdr_fft_demod_0_1_0, '0', lora_sdr_gray_enc_0_1_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_deinterleaver_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_dewhitening_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_fft_demod_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_hamming_dec_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_header_decoder_0, new_frame]
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_frame_sync_0_0, new_frame, lora_sdr_deinterleaver_0_0, new_frame]
- [lora_sdr_frame_sync_0_0, new_frame, lora_sdr_dewhitening_0_0, new_frame]
- [lora_sdr_frame_sync_0_0, new_frame, lora_sdr_fft_demod_0_0, new_frame]
- [lora_sdr_frame_sync_0_0, new_frame, lora_sdr_hamming_dec_0_0, new_frame]
- [lora_sdr_frame_sync_0_0, new_frame, lora_sdr_header_decoder_0_0, new_frame]
- [lora_sdr_frame_sync_0_1, '0', lora_sdr_fft_demod_0_1, '0']
- [lora_sdr_frame_sync_0_1, new_frame, lora_sdr_deinterleaver_0_1, new_frame]
- [lora_sdr_frame_sync_0_1, new_frame, lora_sdr_dewhitening_0_1, new_frame]
- [lora_sdr_frame_sync_0_1, new_frame, lora_sdr_fft_demod_0_1, new_frame]
- [lora_sdr_frame_sync_0_1, new_frame, lora_sdr_hamming_dec_0_1, new_frame]
- [lora_sdr_frame_sync_0_1, new_frame, lora_sdr_header_decoder_0_1, new_frame]
- [lora_sdr_frame_sync_0_1_0, '0', lora_sdr_fft_demod_0_1_0, '0']
- [lora_sdr_frame_sync_0_1_0, new_frame, lora_sdr_deinterleaver_0_1_0, new_frame]
- [lora_sdr_frame_sync_0_1_0, new_frame, lora_sdr_dewhitening_0_1_0, new_frame]
- [lora_sdr_frame_sync_0_1_0, new_frame, lora_sdr_fft_demod_0_1_0, new_frame]
- [lora_sdr_frame_sync_0_1_0, new_frame, lora_sdr_hamming_dec_0_1_0, new_frame]
- [lora_sdr_frame_sync_0_1_0, new_frame, lora_sdr_header_decoder_0_1_0, new_frame]
- [lora_sdr_gray_decode_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_decode_0_0, '0', lora_sdr_modulate_0_0, '0']
- [lora_sdr_gray_decode_0_0_0, '0', lora_sdr_modulate_0_0_0, '0']
- [lora_sdr_gray_decode_0_0_0_0, '0', lora_sdr_modulate_0_0_0_0, '0']
- [lora_sdr_gray_enc_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_gray_enc_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_gray_enc_0_1, '0', lora_sdr_deinterleaver_0_1, '0']
- [lora_sdr_gray_enc_0_1_0, '0', lora_sdr_deinterleaver_0_1_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_dec_0_1, '0', lora_sdr_header_decoder_0_1, '0']
- [lora_sdr_hamming_dec_0_1_0, '0', lora_sdr_header_decoder_0_1_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_hamming_enc_0_0_0, '0', lora_sdr_interleaver_0_0_0, '0']
- [lora_sdr_hamming_enc_0_0_0_0, '0', lora_sdr_interleaver_0_0_0_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_add_crc_0_0, '0']
- [lora_sdr_header_0_0_0, '0', lora_sdr_add_crc_0_0_0, '0']
- [lora_sdr_header_0_0_0_0, '0', lora_sdr_add_crc_0_0_0_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, CR, lora_sdr_deinterleaver_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_dewhitening_0, CRC]
- [lora_sdr_header_decoder_0, CR, lora_sdr_fft_demod_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_frame_sync_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_hamming_dec_0, CR]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_crc_verif_0, CRC]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_frame_sync_0, crc]
- [lora_sdr_header_decoder_0, err, lora_sdr_frame_sync_0, err]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_crc_verif_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_dewhitening_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_frame_sync_0, pay_len]
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, CR, lora_sdr_deinterleaver_0_0, CR]
- [lora_sdr_header_decoder_0_0, CR, lora_sdr_fft_demod_0_0, CR]
- [lora_sdr_header_decoder_0_0, CR, lora_sdr_frame_sync_0_0, CR]
- [lora_sdr_header_decoder_0_0, CR, lora_sdr_hamming_dec_0_0, CR]
- [lora_sdr_header_decoder_0_0, CRC, lora_sdr_crc_verif_0_0, CRC]
- [lora_sdr_header_decoder_0_0, CRC, lora_sdr_dewhitening_0_0, CRC]
- [lora_sdr_header_decoder_0_0, CRC, lora_sdr_frame_sync_0_0, crc]
- [lora_sdr_header_decoder_0_0, err, lora_sdr_frame_sync_0_0, err]
- [lora_sdr_header_decoder_0_0, pay_len, lora_sdr_crc_verif_0_0, pay_len]
- [lora_sdr_header_decoder_0_0, pay_len, lora_sdr_dewhitening_0_0, pay_len]
- [lora_sdr_header_decoder_0_0, pay_len, lora_sdr_frame_sync_0_0, pay_len]
- [lora_sdr_header_decoder_0_1, '0', lora_sdr_dewhitening_0_1, '0']
- [lora_sdr_header_decoder_0_1, CR, lora_sdr_deinterleaver_0_1, CR]
- [lora_sdr_header_decoder_0_1, CR, lora_sdr_fft_demod_0_1, CR]
- [lora_sdr_header_decoder_0_1, CR, lora_sdr_frame_sync_0_1, CR]
- [lora_sdr_header_decoder_0_1, CR, lora_sdr_hamming_dec_0_1, CR]
- [lora_sdr_header_decoder_0_1, CRC, lora_sdr_crc_verif_0_1, CRC]
- [lora_sdr_header_decoder_0_1, CRC, lora_sdr_dewhitening_0_1, CRC]
- [lora_sdr_header_decoder_0_1, CRC, lora_sdr_frame_sync_0_1, crc]
- [lora_sdr_header_decoder_0_1, err, lora_sdr_frame_sync_0_1, err]
- [lora_sdr_header_decoder_0_1, pay_len, lora_sdr_crc_verif_0_1, pay_len]
- [lora_sdr_header_decoder_0_1, pay_len, lora_sdr_dewhitening_0_1, pay_len]
- [lora_sdr_header_decoder_0_1, pay_len, lora_sdr_frame_sync_0_1, pay_len]
- [lora_sdr_header_decoder_0_1_0, '0', lora_sdr_dewhitening_0_1_0, '0']
- [lora_sdr_header_decoder_0_1_0, CR, lora_sdr_deinterleaver_0_1_0, CR]
- [lora_sdr_header_decoder_0_1_0, CR, lora_sdr_fft_demod_0_1_0, CR]
- [lora_sdr_header_decoder_0_1_0, CR, lora_sdr_frame_sync_0_1_0, CR]
- [lora_sdr_header_decoder_0_1_0, CR, lora_sdr_hamming_dec_0_1_0, CR]
- [lora_sdr_header_decoder_0_1_0, CRC, lora_sdr_crc_verif_0_1_0, CRC]
- [lora_sdr_header_decoder_0_1_0, CRC, lora_sdr_dewhitening_0_1_0, CRC]
- [lora_sdr_header_decoder_0_1_0, CRC, lora_sdr_frame_sync_0_1_0, crc]
- [lora_sdr_header_decoder_0_1_0, err, lora_sdr_frame_sync_0_1_0, err]
- [lora_sdr_header_decoder_0_1_0, pay_len, lora_sdr_crc_verif_0_1_0, pay_len]
- [lora_sdr_header_decoder_0_1_0, pay_len, lora_sdr_dewhitening_0_1_0, pay_len]
- [lora_sdr_header_decoder_0_1_0, pay_len, lora_sdr_frame_sync_0_1_0, pay_len]
- [lora_sdr_hier_tx_0, '0', blocks_throttle_0, '0']
- [lora_sdr_hier_tx_0_1, '0', blocks_throttle_0_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_decode_0, '0']
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_decode_0_0, '0']
- [lora_sdr_interleaver_0_0_0, '0', lora_sdr_gray_decode_0_0_0, '0']
- [lora_sdr_interleaver_0_0_0_0, '0', lora_sdr_gray_decode_0_0_0_0, '0']
- [lora_sdr_modulate_0, '0', blocks_throttle_0_1, '0']
- [lora_sdr_modulate_0_0, '0', blocks_throttle_1, '0']
- [lora_sdr_modulate_0_0_0, '0', blocks_throttle_1_0, '0']
- [lora_sdr_modulate_0_0_0_0, '0', blocks_throttle_0_1_0_0_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0_0, '0']
- [lora_sdr_whitening_0_0_0, '0', lora_sdr_header_0_0_0, '0']
- [lora_sdr_whitening_0_0_0_0, '0', lora_sdr_header_0_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_streams_0_0, '0']
- [rational_resampler_xxx_0_1_0, '0', lora_sdr_frame_sync_0, '0']
- [rational_resampler_xxx_0_1_1_0, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0_1_1_0, '0', blocks_streams_to_stream_0, '1']
- [rational_resampler_xxx_0_1_1_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', lora_sdr_frame_sync_0, '0']
- [virtual_source_0, '0', lora_sdr_frame_sync_0_0, '0']
- [virtual_source_0, '0', lora_sdr_frame_sync_0_1, '0']

metadata:
  file_format: 1
