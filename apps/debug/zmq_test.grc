options:
  parameters:
    generate_options: no_gui
    id: zmq_test
    output_language: cpp
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mean
  id: variable
  parameters:
    value: '200'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '10'
  states: {}
- name: noise
  id: variable
  parameters:
    value: '15'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '9'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: channels_channel_model_0_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 0.0j
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_1_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: '20000'
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccf
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_1_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: '20000'
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccc
  states: {}
- name: lora_sdr_frame_detector_0
  id: lora_sdr_frame_detector
  parameters:
    bw: bw
    samp_rate: samp_rate
    sf: sf
    threshold: '200'
  states: {state: disabled}
- name: lora_sdr_frame_detector_2
  id: lora_sdr_frame_detector
  parameters:
    bw: bw
    minoutbuf: '20000'
    samp_rate: samp_rate
    sf: sf
    threshold: '200'
  states: {}
- name: lora_sdr_hier_rx_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    exit: 'True'
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8, 16]'
  states: {state: disabled}
- name: lora_sdr_hier_rx_1
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    exit: 'true'
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8, 16]'
  states: {}
- name: lora_sdr_hier_tx_1
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: mean
    multi_control: 'true'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: '"TrccpfQHyKfvXswsA4ySxtTiIvi10nSJCUJPYonkWqDHH005UmNfGuocPw3FHKc9"'
    sync_words: '[8, 16]'
  states: {}
- name: lora_sdr_signal_detector_0
  id: lora_sdr_signal_detector
  parameters:
    fft_symb: '4'
    margin: '0'
    os_factor: '1'
    sf: sf
    threshold: '10'
    transp_len: '10'
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0_1_0, '0']
- [blocks_throttle_0_1_0, '0', lora_sdr_frame_detector_0, '0']
- [blocks_throttle_0_1_0, '0', lora_sdr_frame_detector_2, '0']
- [blocks_throttle_0_1_0, '0', lora_sdr_signal_detector_0, '0']
- [channels_channel_model_0_0_0, '0', interp_fir_filter_xxx_0_1_0, '0']
- [interp_fir_filter_xxx_0_1_0, '0', lora_sdr_hier_rx_0, '0']
- [interp_fir_filter_xxx_0_1_0_0, '0', lora_sdr_hier_rx_1, '0']
- [lora_sdr_frame_detector_0, '0', channels_channel_model_0_0_0, '0']
- [lora_sdr_frame_detector_2, '0', interp_fir_filter_xxx_0_1_0_0, '0']
- [lora_sdr_hier_tx_1, '0', blocks_add_xx_0, '0']
- [lora_sdr_signal_detector_0, '0', blocks_null_sink_0_0, '0']

metadata:
  file_format: 1
