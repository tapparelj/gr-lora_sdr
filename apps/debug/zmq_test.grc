options:
  parameters:
    gen_cmake: 'Off'
    generate_options: no_gui
    id: zmq_test
    output_language: cpp
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mean
  id: variable
  parameters:
    value: '200'
  states: {}
- name: multi_control
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '3'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '9'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    filter: ''
    name: work_done
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"work_done"'
    name: work_done
    type: int
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"work_done"'
    name: after crc
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"work_done"'
    name: before_crc
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: lora_sdr_add_crc_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_data_source_sim_0
  id: lora_sdr_data_source_sim
  parameters:
    mean: '200'
    multi_control: 'True'
    n_frames: n_frame
    pay_len: '64'
    string_input: '"ssKTiomvPXMuARfDvU5zzMIoQfJlOtZ4LxNSJ0dmLOGctMDOuzeTbK8PPH0r0NmA"'
  states: {}
- name: lora_sdr_gray_decode_0_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_modulate_0_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    create_zeros: 'False'
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8,16]'
  states: {}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}

connections:
- [blocks_throttle_0_1, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0_1, '0', blocks_tag_debug_1_0, '0']
- [lora_sdr_add_crc_0_0, '0', blocks_tag_debug_1_0_0_0, '0']
- [lora_sdr_add_crc_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_data_source_sim_0, '0', lora_sdr_whitening_0_0, '0']
- [lora_sdr_data_source_sim_0, msg, lora_sdr_whitening_0_0, msg]
- [lora_sdr_gray_decode_0_0, '0', blocks_tag_debug_1_0_0, '0']
- [lora_sdr_gray_decode_0_0, '0', lora_sdr_modulate_0_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_header_0_0, '0', blocks_tag_debug_1_0_0_0_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_add_crc_0_0, '0']
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_decode_0_0, '0']
- [lora_sdr_modulate_0_0, '0', blocks_throttle_0_1, '0']
- [lora_sdr_whitening_0_0, '0', lora_sdr_header_0_0, '0']

metadata:
  file_format: 1
