options:
  parameters:
    generate_options: no_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: input_vec
  id: variable
  parameters:
    value: (1,2,3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: lora_sdr_frame_reciever_0
  id: lora_sdr_frame_reciever
  parameters:
    addres: localhost
    mode: 'True'
    port: '5555'
    service: Rx
  states: {}
- name: lora_sdr_hier_rx_0
  id: lora_sdr_hier_rx
  parameters:
    bw: ''
    cr: ''
    exit: 'True'
    has_crc: 'False'
    impl_head: ''
    pay_len: ''
    samp_rate: ''
    sf: ''
    sync_words: '[8, 16]'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_rep_msg_sink_0
  id: zeromq_rep_msg_sink
  parameters:
    timeout: '100'
  states: {state: disabled}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [lora_sdr_frame_reciever_0, '0', blocks_null_sink_0, '0']
- [lora_sdr_frame_reciever_0, '0', lora_sdr_hier_rx_0, '0']
- [lora_sdr_frame_reciever_0, '0', qtgui_sink_x_0, '0']
- [zeromq_pull_source_0, '0', blocks_null_sink_0, '0']
- [zeromq_pull_source_0, '0', qtgui_sink_x_0, '0']
- [zeromq_req_source_0, '0', blocks_null_sink_0, '0']
- [zeromq_req_source_0, '0', qtgui_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_null_sink_0, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
