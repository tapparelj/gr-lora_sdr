options:
  parameters:
    description: example of a configuration that send and receives frames for BER measurement (here the two USRPs are linked by a MIMO cable)
    generate_options: no_gui
    id: lora_tx_rx
    output_language: python
  states: {}

blocks:
- name: TX_gain
  id: variable
  parameters:
    value: '3'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '200'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: frame_period
    msg: pmt.intern('')
    std: '5'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mult_const
    minoutbuf: '10000000'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    taps: "-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872"
    type: ccf
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_data_source_0
  id: lora_sdr_data_source
  parameters:
    n_frames: n_frame
    pay_len: pay_len
    string_input: ''
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_err_measures_0
  id: lora_sdr_err_measures
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_gray_decode_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_enc_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: 915e6
    clock_rate: '0.0'
    dev_addr: '"addr0=192.168.10.2,addr1=192.168.10.3"'
    gain0: TX_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    bw1: bw
    center_freq0: '0'
    center_freq1: 915e6
    clock_rate: '0.0'
    clock_source1: mimo
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr0=192.168.10.2,addr1=192.168.10.3"'
    gain0: '0'
    gain1: '31.5'
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    time_source1: mimo
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, lora_sdr_data_source_0, trigg]
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, msg, lora_sdr_err_measures_0, msg]
- [lora_sdr_data_source_0, '0', lora_sdr_whitening_0, '0']
- [lora_sdr_data_source_0, msg, lora_sdr_add_crc_0, msg]
- [lora_sdr_data_source_0, msg, lora_sdr_err_measures_0, ref]
- [lora_sdr_data_source_0, msg, lora_sdr_header_0, msg]
- [lora_sdr_data_source_0, msg, lora_sdr_interleaver_0, msg]
- [lora_sdr_data_source_0, msg, lora_sdr_modulate_0, msg]
- [lora_sdr_data_source_0, msg, lora_sdr_whitening_0, msg]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_enc_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_deinterleaver_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_dewhitening_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_fft_demod_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_hamming_dec_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_header_decoder_0, new_frame]
- [lora_sdr_gray_decode_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_enc_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, CR, lora_sdr_deinterleaver_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_fft_demod_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_frame_sync_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_hamming_dec_0, CR]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_crc_verif_0, CRC]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_dewhitening_0, CRC]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_frame_sync_0, crc]
- [lora_sdr_header_decoder_0, err, lora_sdr_frame_sync_0, err]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_crc_verif_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_dewhitening_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_frame_sync_0, pay_len]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_decode_0, '0']
- [lora_sdr_modulate_0, '0', blocks_multiply_const_vxx_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '1', interp_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
