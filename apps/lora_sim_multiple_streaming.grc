options:
  parameters:
    author: Martyn van Dijke
    generate_options: no_gui
    id: lora_sim_multi
    output_language: python
    title: Simulated multi stream
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '8'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("")
    period: '200'
  states: {}
- name: blocks_message_strobe_random_0_1_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: frame_period
    msg: pmt.intern('')
    std: '5'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_sdr_hier_rx_0_0_0_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '9'
  states: {}
- name: lora_sdr_hier_rx_0_1_0_0_0_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '12'
  states: {state: disabled}
- name: lora_sdr_hier_rx_0_1_0_0_0_0_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '8'
  states: {}
- name: lora_sdr_hier_rx_0_1_0_0_1
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '11'
  states: {state: disabled}
- name: lora_sdr_hier_rx_0_1_0_0_1_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: lora_sdr_hier_rx_0_2_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '10'
  states: {}
- name: lora_sdr_hier_tx_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: DkzTEkJgm4nWmmhHddkGq6BUa7xfto3CdAlyRumnKgshlfxA73xvXnCIRRYefeZY
  states: {}
- name: lora_sdr_hier_tx_0_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: '8'
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, lora_sdr_hier_tx_0, trigg]
- [blocks_message_strobe_0, strobe, lora_sdr_hier_tx_0_0, trigg]
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_hier_tx_0, trigg]
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_hier_tx_0_0, trigg]
- [blocks_throttle_0, '0', rational_resampler_xxx_0_1, '0']
- [lora_sdr_hier_tx_0, '0', blocks_add_xx_0, '1']
- [lora_sdr_hier_tx_0_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_0_1, '0', lora_sdr_hier_rx_0_0_0_0, '0']
- [rational_resampler_xxx_0_1, '0', lora_sdr_hier_rx_0_1_0_0_0_0, '0']
- [rational_resampler_xxx_0_1, '0', lora_sdr_hier_rx_0_1_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_1, '0', lora_sdr_hier_rx_0_1_0_0_1, '0']
- [rational_resampler_xxx_0_1, '0', lora_sdr_hier_rx_0_1_0_0_1_0, '0']
- [rational_resampler_xxx_0_1, '0', lora_sdr_hier_rx_0_2_0, '0']

metadata:
  file_format: 1
