options:
  parameters:
    author: Martyn
    cmake_opt: '""'
    description: Simulation example LoRa
    generate_options: no_gui
    id: lora_sim
    output_language: python
    run_options: run
    thread_safe_setters: '1'
    title: test
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: multi_control
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '5'
  states: {}
- name: noise
  id: variable
  parameters:
    value: '5'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '12'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '10'
  states: {}
- name: time_wait
  id: variable
  parameters:
    value: '200'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_UNIFORM
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"frame"'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"frame"'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: interp_fir_filter_xxx_0_1_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf*8
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccf
  states: {}
- name: lora_sdr_frame_detector_1
  id: lora_sdr_frame_detector
  parameters:
    bw: bw
    minoutbuf: 2**sf*8
    samp_rate: samp_rate
    sf: sf
    threshold: '600'
  states: {}
- name: lora_sdr_hier_rx_1
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    exit: 'True'
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8, 16]'
  states: {}
- name: lora_sdr_hier_tx_1
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: time_wait
    minoutbuf: 2**sf*8
    multi_control: 'True'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: '"TrccpfQHyKfvXswsA4ySxtTiIvi10nSJCUJPYonkWqDHH005UmNfGuocPw3FHKc9"'
    sync_words: '[8, 16]'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0_1_0, '0']
- [blocks_throttle_0_1_0, '0', lora_sdr_frame_detector_1, '0']
- [interp_fir_filter_xxx_0_1_0, '0', blocks_tag_debug_0, '0']
- [interp_fir_filter_xxx_0_1_0, '0', blocks_tag_debug_0_0, '0']
- [interp_fir_filter_xxx_0_1_0, '0', lora_sdr_hier_rx_1, '0']
- [lora_sdr_frame_detector_1, '0', interp_fir_filter_xxx_0_1_0, '0']
- [lora_sdr_hier_tx_1, '0', blocks_throttle_0_1_0, '0']

metadata:
  file_format: 1
