options:
  parameters:
    description: Simulation example LoRa
    generate_options: no_gui
    id: lora_sim
    output_language: python
    run_options: run
    thread_safe_setters: '1'
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mean
  id: variable
  parameters:
    value: '200'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: multi_control
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '10'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '9'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(pay_len*2*1)
    type: byte
  states: {state: bypassed}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 0.0j
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: '20000'
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccf
  states: {}
- name: lora_sdr_add_crc_0_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0_0
  id: lora_sdr_crc_verif
  parameters:
    exit: 'True'
  states: {}
- name: lora_sdr_data_source_sim_0
  id: lora_sdr_data_source_sim
  parameters:
    mean: '200'
    multi_control: 'False'
    n_frames: '5'
    pay_len: '64'
    string_input: ''
  states: {}
- name: lora_sdr_deinterleaver_0_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_dewhitening_0_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0_0
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_frame_detector_0
  id: lora_sdr_frame_detector
  parameters:
    bw: bw
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_sdr_frame_sync_0_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8, 16]'
  states: {}
- name: lora_sdr_gray_decode_0_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_enc_0_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_enc_0_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_hier_rx_0_1_0_0_1_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    exit: 'True'
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_sdr_hier_tx_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'True'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {state: disabled}
- name: lora_sdr_interleaver_0_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_modulate_0_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    create_zeros: 'False'
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8, 16]'
  states: {}
- name: lora_sdr_whitening_0_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}

connections:
- [blocks_head_0, '0', lora_sdr_header_0_0, '0']
- [blocks_throttle_0_0, '0', lora_sdr_frame_detector_0, '0']
- [blocks_throttle_0_1, '0', channels_channel_model_0_0, '0']
- [channels_channel_model_0_0, '0', interp_fir_filter_xxx_0_1, '0']
- [interp_fir_filter_xxx_0_0, '0', lora_sdr_hier_rx_0_1_0_0_1_0, '0']
- [interp_fir_filter_xxx_0_1, '0', lora_sdr_frame_sync_0_0, '0']
- [lora_sdr_add_crc_0_0, '0', lora_sdr_hamming_enc_0_0, '0']
- [lora_sdr_data_source_sim_0, '0', lora_sdr_whitening_0_0, '0']
- [lora_sdr_data_source_sim_0, msg, lora_sdr_whitening_0_0, msg]
- [lora_sdr_deinterleaver_0_0, '0', lora_sdr_hamming_dec_0_0, '0']
- [lora_sdr_dewhitening_0_0, '0', lora_sdr_crc_verif_0_0, '0']
- [lora_sdr_fft_demod_0_0, '0', lora_sdr_gray_enc_0_0, '0']
- [lora_sdr_frame_sync_0_0, '0', lora_sdr_fft_demod_0_0, '0']
- [lora_sdr_gray_decode_0_0, '0', lora_sdr_modulate_0_0, '0']
- [lora_sdr_gray_enc_0_0, '0', lora_sdr_deinterleaver_0_0, '0']
- [lora_sdr_hamming_dec_0_0, '0', lora_sdr_header_decoder_0_0, '0']
- [lora_sdr_hamming_enc_0_0, '0', lora_sdr_interleaver_0_0, '0']
- [lora_sdr_header_0_0, '0', lora_sdr_add_crc_0_0, '0']
- [lora_sdr_header_decoder_0_0, '0', lora_sdr_dewhitening_0_0, '0']
- [lora_sdr_header_decoder_0_0, frame_info, lora_sdr_frame_sync_0_0, frame_info]
- [lora_sdr_interleaver_0_0, '0', lora_sdr_gray_decode_0_0, '0']
- [lora_sdr_modulate_0_0, '0', blocks_throttle_0_1, '0']
- [lora_sdr_whitening_0_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
