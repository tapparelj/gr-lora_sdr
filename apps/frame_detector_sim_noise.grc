options:
  parameters:
    author: Martyn van Dijke
    cmake_opt: '""'
    description: Simulation example LoRa
    generate_options: no_gui
    id: frame_detector
    output_language: python
    run_options: run
    thread_safe_setters: '1'
    title: Frame detector test with noise and cfo
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: cfo
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: delay
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: multi_control
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: snr
  id: variable
  parameters:
    value: '-7'
  states: {}
- name: sto
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1.5'
  states: {}
- name: time_wait
  id: variable
  parameters:
    value: '200'
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1+cfo*samp_rate/center_freq/2**sf
    freq_offset: cfo
    minoutbuf: 2**sf*8
    noise_voltage: 10**(-snr/20)
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_1_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf*8
    taps: "(-0.128616616593872,\t-0.212206590789194,\t-0.180063263231421,\t3.89817183251938e-17\t,0.300105438719035\t,0.636619772367581\t,0.900316316157106,\t1\t,0.900316316157106,\t0.636619772367581,\t0.300105438719035,\t3.89817183251938e-17,\t-0.180063263231421,\t-0.212206590789194,\t-0.128616616593872)"
    type: ccf
  states: {state: disabled}
- name: lora_sdr_frame_detector_1
  id: lora_sdr_frame_detector
  parameters:
    bw: bw
    minoutbuf: 2**sf*8
    samp_rate: samp_rate
    sf: sf
    threshold: threshold
  states: {state: disabled}
- name: lora_sdr_frame_detector_timeout_0
  id: lora_sdr_frame_detector_timeout
  parameters:
    bw: bw
    detect_second_packet: 'True'
    n_bytes: '150'
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_sdr_frame_detector_timeout_0_0
  id: lora_sdr_frame_detector_timeout
  parameters:
    bw: bw
    detect_second_packet: 'False'
    n_bytes: '150'
    samp_rate: samp_rate
    sf: sf
  states: {state: disabled}
- name: lora_sdr_frame_reciever_0
  id: lora_sdr_frame_reciever
  parameters:
    addres: localhost
    mode: 'True'
    port: '5555'
    service: echo
  states: {}
- name: lora_sdr_frame_sender_0
  id: lora_sdr_frame_sender
  parameters:
    addres: localhost
    bw: bw
    compress: 'True'
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mode: 'True'
    pay_len: pay_len
    port: '5555'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8, 16]'
  states: {state: disabled}
- name: lora_sdr_hier_rx_1
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    exit: 'True'
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8, 16]'
  states: {state: disabled}
- name: lora_sdr_hier_tx_1
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: time_wait
    minoutbuf: 2**sf*8
    multi_control: 'False'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: ''
    sync_words: '[8, 16]'
  states: {state: disabled}

connections:
- [blocks_throttle_0_1_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', lora_sdr_frame_detector_1, '0']
- [channels_channel_model_0, '0', lora_sdr_frame_detector_timeout_0, '0']
- [interp_fir_filter_xxx_0_1_0, '0', lora_sdr_hier_rx_1, '0']
- [lora_sdr_frame_detector_1, '0', interp_fir_filter_xxx_0_1_0, '0']
- [lora_sdr_frame_detector_timeout_0, '0', interp_fir_filter_xxx_0_1_0, '0']
- [lora_sdr_frame_detector_timeout_0_0, '0', lora_sdr_frame_sender_0, '0']
- [lora_sdr_frame_reciever_0, '0', blocks_null_sink_0_0, '0']
- [lora_sdr_hier_tx_1, '0', blocks_throttle_0_1_0, '0']
- [lora_sdr_hier_tx_1, '0', lora_sdr_frame_detector_timeout_0_0, '0']

metadata:
  file_format: 1
