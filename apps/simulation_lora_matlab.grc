options:
  parameters:
    author: Martyn van Dijke
    generate_options: qt_gui
    id: sim_lora_matlab
    output_language: python
    run_options: run
    title: Simulation LoRa matlab
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '3'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '80'
  states: {}
- name: num_recv
  id: variable
  parameters:
    value: '1'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/martyn/gr-lora_sdr/test/tx_out.dat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/martyn/gr-lora_sdr/test/mod_out.dat
    type: int
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/martyn/gr-lora_sdr/test/gray_out.dat
    type: int
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/martyn/gr-lora_sdr/test/interleave_out.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/martyn/gr-lora_sdr/test/header_out.dat
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/martyn/gr-lora_sdr/test/whitening_out.dat
    type: byte
  states: {}
- name: blocks_message_strobe_random_0_1_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: frame_period
    msg: pmt.intern('')
    std: '5'
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: int
  states: {}
- name: blocks_stream_to_streams_0_0
  id: blocks_stream_to_streams
  parameters:
    type: int
  states: {}
- name: blocks_stream_to_streams_0_0_0
  id: blocks_stream_to_streams
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_streams_0_0_0_0
  id: blocks_stream_to_streams
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_streams_0_0_0_0_0
  id: blocks_stream_to_streams
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_streams_0_1
  id: blocks_stream_to_streams
  parameters:
    num_streams: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters: {}
  states: {}
- name: lora_sdr_data_source_0_1_0
  id: lora_sdr_data_source
  parameters:
    n_frames: n_frame
    pay_len: pay_len
    string_input: ''
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_err_measures_0
  id: lora_sdr_err_measures
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    bandwidth: bw
    impl_head: impl_head
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    impl_head: impl_head
    num_recv: num_recv
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_gray_decode_0
  id: lora_sdr_gray_decode
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_enc_0
  id: lora_sdr_gray_enc
  parameters: {}
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters: {}
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    minoutbuf: '10000000'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_message_strobe_random_0_1_0, strobe, lora_sdr_data_source_0_1_0, trigg]
- [blocks_stream_to_streams_0, '0', lora_sdr_gray_enc_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_file_sink_0_0, '0']
- [blocks_stream_to_streams_0_0, '0', lora_sdr_deinterleaver_0, '0']
- [blocks_stream_to_streams_0_0, '1', blocks_file_sink_0_0_0, '0']
- [blocks_stream_to_streams_0_0_0, '0', lora_sdr_hamming_dec_0, '0']
- [blocks_stream_to_streams_0_0_0, '1', blocks_file_sink_0_0_0_0, '0']
- [blocks_stream_to_streams_0_0_0_0, '0', lora_sdr_dewhitening_0, '0']
- [blocks_stream_to_streams_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0, '0']
- [blocks_stream_to_streams_0_0_0_0_0, '0', lora_sdr_crc_verif_0, '0']
- [blocks_stream_to_streams_0_0_0_0_0, '1', blocks_file_sink_0_0_0_0_0_0, '0']
- [blocks_stream_to_streams_0_1, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_streams_0_1, '1', lora_sdr_frame_sync_0, '0']
- [blocks_stream_to_streams_0_1, '2', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, msg, lora_sdr_err_measures_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_add_crc_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_err_measures_0, ref]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_header_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_interleaver_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_modulate_0, msg]
- [lora_sdr_data_source_0_1_0, msg, lora_sdr_whitening_0, msg]
- [lora_sdr_deinterleaver_0, '0', blocks_stream_to_streams_0_0_0, '0']
- [lora_sdr_dewhitening_0, '0', blocks_stream_to_streams_0_0_0_0_0, '0']
- [lora_sdr_fft_demod_0, '0', blocks_stream_to_streams_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_deinterleaver_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_dewhitening_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_fft_demod_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_hamming_dec_0, new_frame]
- [lora_sdr_frame_sync_0, new_frame, lora_sdr_header_decoder_0, new_frame]
- [lora_sdr_gray_decode_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_enc_0, '0', blocks_stream_to_streams_0_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', blocks_stream_to_streams_0_0_0_0, '0']
- [lora_sdr_header_decoder_0, CR, lora_sdr_deinterleaver_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_fft_demod_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_frame_sync_0, CR]
- [lora_sdr_header_decoder_0, CR, lora_sdr_hamming_dec_0, CR]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_crc_verif_0, CRC]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_dewhitening_0, CRC]
- [lora_sdr_header_decoder_0, CRC, lora_sdr_frame_sync_0, crc]
- [lora_sdr_header_decoder_0, err, lora_sdr_frame_sync_0, err]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_crc_verif_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_dewhitening_0, pay_len]
- [lora_sdr_header_decoder_0, pay_len, lora_sdr_frame_sync_0, pay_len]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_decode_0, '0']
- [lora_sdr_modulate_0, '0', blocks_throttle_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_streams_0_1, '0']

metadata:
  file_format: 1
