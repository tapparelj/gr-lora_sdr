options:
  parameters:
    description: example of a configuration that send and receives frames for BER measurement (here the two USRPs are linked by a MIMO cable)
    generate_options: no_gui
    id: mu_tx_rx
    output_language: python
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: calib_off_u2
  id: variable
  parameters:
    comment: |-
      Can be used to set an offset to user 2 power that
      corresponds to the output power difference between
      the two Tx radios during calibration.
    value: '0.4'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: cfo
  id: variable
  parameters:
    value: '[0.0,0.0]'
  states: {}
- name: delay
  id: variable
  parameters:
    value: int(400*os_factor_tx*2**sf)
  states: {}
- name: measurement_folder
  id: variable
  parameters:
    comment: Folder where the the measurements will be saved
    value: '"/home/jtappare/Documents/lora_gnu_radio_prototype/gr-lora_sdr/matlab/measurements"'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: os_factor_rx
  id: variable
  parameters:
    value: '8'
  states: {}
- name: os_factor_tx
  id: variable
  parameters:
    value: '8'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: power
  id: variable
  parameters:
    comment: |-
      Power of each user in dB. Should be negative as the
      input of UHD: USRP Sink saturate for samples values
      greater than 1.
    value: '[0,0]'
  states: {}
- name: rand_sto
  id: variable
  parameters:
    value: '[False,False]'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '8'
  states: {}
- name: snr_thres
  id: variable
  parameters:
    value: '-9'
  states: {}
- name: sto
  id: variable
  parameters:
    value: '[0.0,0.0]'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 10**(-4.2/20.0)
    comment: Can be used to roughly set the CFO between Tx and Rx
    freq: '-9.4*samp_rate/2**sf'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*os_factor_tx
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    comment: |-
      Delay used to estimate the noise power in the
      beginning of transmission
    delay: 2**sf*os_factor_tx*150
    type: complex
  states: {}
- name: blocks_delay_0_0_2
  id: blocks_delay
  parameters:
    delay: int(2**sf*os_factor_tx*150)
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_demod_s1.txt"
    type: short
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_demod_s2.txt"
    type: short
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_snr.txt"
    type: float
  states: {}
- name: blocks_file_sink_1_0_1
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/sync_state.txt"
    type: int
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_source_s1.txt"
    type: short
  states: {}
- name: blocks_file_sink_3_0
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_source_s2.txt"
    type: short
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    minoutbuf: 2**sf*os_factor_rx*30
    n: os_factor_rx
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**((power[0])/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**((power[1]+calib_off_u2)/20.0)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: lora_sdr_frame_src_0
  id: lora_sdr_frame_src
  parameters:
    cfo: cfo[0]
    delay: delay
    n_frames: n_frame
    offset: int(np.round(sto[0]*os_factor_tx))
    os_factor: os_factor_tx
    pay_len: pay_len
    rand_sto: rand_sto[0]
    sf: sf
  states: {}
- name: lora_sdr_frame_src_0_0
  id: lora_sdr_frame_src
  parameters:
    cfo: cfo[1]
    delay: delay
    n_frames: n_frame
    offset: int(np.round((15*2**sf+sto[1])*os_factor_tx))
    os_factor: os_factor_tx
    pay_len: pay_len
    rand_sto: rand_sto[1]
    sf: sf
  states: {}
- name: lora_sdr_mu_demod_0
  id: lora_sdr_mu_demod
  parameters:
    Ku: '5'
    minoutbuf: 2**sf*200
    sf: sf
  states: {}
- name: lora_sdr_mu_detection_0
  id: lora_sdr_mu_detection
  parameters:
    minoutbuf: 2**sf*os_factor_rx*200
    os_factor: os_factor_rx
    sf: sf
    snr_threshold: snr_thres
  states: {}
- name: lora_sdr_mu_synchro_0
  id: lora_sdr_mu_synchro
  parameters:
    len: pay_len
    minoutbuf: 2**sf*200
    os_factor: os_factor_rx
    sf: sf
  states: {}
- name: lora_sdr_noise_est_0
  id: lora_sdr_noise_est
  parameters:
    n_samples: 2**sf*30
  states: {}
- name: lora_sdr_signal_detector_0
  id: lora_sdr_signal_detector
  parameters:
    fft_symb: '4'
    margin: '8'
    minoutbuf: 2**sf*os_factor_rx*800
    os_factor: os_factor_rx
    sf: sf
    threshold: '10'
    transp_len: '50'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    bw0: bw
    bw1: bw
    center_freq0: center_freq
    center_freq1: center_freq
    clock_rate: '0.0'
    clock_source1: mimo
    dev_addr: ''
    dev_args: '"addr0=192.168.10.3,addr1=192.168.10.2"'
    gain0: tx_gain
    gain1: tx_gain
    len_tag_name: ''
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    samp_rate: samp_rate*os_factor_tx
    sync: none
    time_source1: mimo
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw*os_factor_rx
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '"addr=192.168.10.4"'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    minoutbuf: 2**sf*os_factor_rx*200
    norm_gain0: 'False'
    samp_rate: bw*os_factor_rx
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_delay_0_0_1, '0', uhd_usrp_sink_0, '1']
- [blocks_delay_0_0_2, '0', uhd_usrp_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', lora_sdr_noise_est_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_delay_0_0_1, '0']
- [blocks_multiply_xx_0_0, '0', blocks_delay_0_0_2, '0']
- [lora_sdr_frame_src_0, '0', blocks_multiply_const_vxx_0, '0']
- [lora_sdr_frame_src_0, '1', blocks_file_sink_3, '0']
- [lora_sdr_frame_src_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [lora_sdr_frame_src_0_0, '1', blocks_file_sink_3_0, '0']
- [lora_sdr_mu_demod_0, '0', blocks_file_sink_1, '0']
- [lora_sdr_mu_demod_0, '1', blocks_file_sink_1_0, '0']
- [lora_sdr_mu_demod_0, '2', blocks_file_sink_1_0_0, '0']
- [lora_sdr_mu_detection_0, '0', lora_sdr_mu_synchro_0, '0']
- [lora_sdr_mu_synchro_0, '0', lora_sdr_mu_demod_0, '0']
- [lora_sdr_mu_synchro_0, '1', blocks_file_sink_1_0_1, '0']
- [lora_sdr_noise_est_0, noise_est, lora_sdr_mu_detection_0, noise_est]
- [lora_sdr_signal_detector_0, '0', lora_sdr_mu_detection_0, '0']
- [uhd_usrp_source_0, '0', blocks_keep_one_in_n_0, '0']
- [uhd_usrp_source_0, '0', lora_sdr_signal_detector_0, '0']

metadata:
  file_format: 1
