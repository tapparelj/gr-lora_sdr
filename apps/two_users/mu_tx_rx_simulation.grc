options:
  parameters:
    description: example of a configuration that send and receives frames for BER measurement (here the two USRPs are linked by a MIMO cable)
    generate_options: no_gui
    id: mu_tx_rx_simulation
    output_language: python
    run_options: run
  states: {}

blocks:
- name: RX_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: TX_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: cfo
  id: variable
  parameters:
    value: '[0.0,0.0]'
  states: {}
- name: delay
  id: variable
  parameters:
    comment: Delay between two frames in number of LoRa symbols.
    value: '400'
  states: {}
- name: measurement_folder
  id: variable
  parameters:
    comment: Folder where the the measurements will be saved
    value: '"/home/jtappare/Documents/lora_gnu_radio_prototype/gr-lora_sdr/matlab/measurements"'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '100'
  states: {}
- name: os_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: pay_len
  id: variable
  parameters:
    comment: Payload length in number of LoRa symbols
    value: '32'
  states: {}
- name: power
  id: variable
  parameters:
    value: '[0,3]'
  states: {}
- name: rand_sto
  id: variable
  parameters:
    value: '[False,False]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: snr_thres
  id: variable
  parameters:
    comment: |-
      Hard SNR threshold used by
      the detection block
      to identify new users
    value: '-9'
  states: {}
- name: sto
  id: variable
  parameters:
    value: '[0.0,32.0]'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    comment: |-
      Delay used to estimate the noise power in the
      beginning of transmission
    delay: 2**sf*os_factor*150
    type: complex
  states: {}
- name: blocks_delay_0_0_2
  id: blocks_delay
  parameters:
    delay: int(2**sf*os_factor*150)
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jtappare/Documents/lora_gnu_radio_prototype/gr-lora_sdr/matlab/debug/partial_ml_out_m1.txt
    type: complex
    vlen: 2**sf
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/jtappare/Documents/lora_gnu_radio_prototype/gr-lora_sdr/matlab/debug/partial_ml_out_m2.txt
    type: complex
    vlen: 2**sf
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_demod_s1.txt"
    type: short
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_demod_s2.txt"
    type: short
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_snr.txt"
    type: float
  states: {}
- name: blocks_file_sink_1_0_1
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/sync_state.txt"
    type: int
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_source_s1.txt"
    type: short
  states: {}
- name: blocks_file_sink_3_0
  id: blocks_file_sink
  parameters:
    file: measurement_folder + "/mu_source_s2.txt"
    type: short
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    minoutbuf: 2**sf*os_factor*30
    n: os_factor
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**((power[0])/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**((power[1])/20.0)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    minoutbuf: 2**sf*os_factor*20
    samples_per_second: samp_rate*os_factor
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: np.sqrt(0)
    seed: '0'
    taps: (1.0/0.9 + 0.0j)*cmath.exp(1j*0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import time,cmath
  states: {}
- name: lora_sdr_frame_src_0
  id: lora_sdr_frame_src
  parameters:
    cfo: cfo[0]
    delay: int(delay*os_factor*2**sf)
    n_frames: n_frame
    offset: int(np.round(sto[0]*os_factor))
    os_factor: os_factor
    pay_len: pay_len
    rand_sto: rand_sto[0]
    sf: sf
  states: {}
- name: lora_sdr_frame_src_0_0
  id: lora_sdr_frame_src
  parameters:
    cfo: cfo[1]
    delay: int(delay*os_factor*2**sf)
    n_frames: n_frame
    offset: int(np.round((15*2**sf+sto[1])*os_factor))
    os_factor: os_factor
    pay_len: pay_len
    rand_sto: rand_sto[1]
    sf: sf
  states: {}
- name: lora_sdr_mu_demod_0
  id: lora_sdr_mu_demod
  parameters:
    Ku: '5'
    minoutbuf: 2**sf*200
    sf: sf
  states: {}
- name: lora_sdr_mu_detection_0
  id: lora_sdr_mu_detection
  parameters:
    minoutbuf: 2**sf*os_factor
    os_factor: os_factor
    sf: sf
    snr_threshold: snr_thres
  states: {}
- name: lora_sdr_mu_synchro_0
  id: lora_sdr_mu_synchro
  parameters:
    len: pay_len
    minoutbuf: 2**sf*200
    os_factor: os_factor
    sf: sf
  states: {}
- name: lora_sdr_noise_est_0
  id: lora_sdr_noise_est
  parameters:
    n_samples: 2**sf*30
  states: {}
- name: lora_sdr_partial_ml_0
  id: lora_sdr_partial_ml
  parameters:
    _id: '0'
    sf: sf
  states: {state: disabled}
- name: lora_sdr_signal_detector_0
  id: lora_sdr_signal_detector
  parameters:
    fft_symb: '4'
    margin: '8'
    minoutbuf: 2**sf*os_factor*10
    os_factor: os_factor
    sf: sf
    threshold: '10'
    transp_len: '50'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rec_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rec_signal
  states: {}

connections:
- [blocks_add_xx_0, '0', channels_channel_model_0, '0']
- [blocks_delay_0_0_1, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0_2, '0', blocks_add_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', lora_sdr_noise_est_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0_0_2, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_delay_0_0_1, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [lora_sdr_frame_src_0, '0', blocks_multiply_const_vxx_0, '0']
- [lora_sdr_frame_src_0, '1', blocks_file_sink_3, '0']
- [lora_sdr_frame_src_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [lora_sdr_frame_src_0_0, '1', blocks_file_sink_3_0, '0']
- [lora_sdr_mu_demod_0, '0', blocks_file_sink_1, '0']
- [lora_sdr_mu_demod_0, '1', blocks_file_sink_1_0, '0']
- [lora_sdr_mu_demod_0, '2', blocks_file_sink_1_0_0, '0']
- [lora_sdr_mu_detection_0, '0', lora_sdr_mu_synchro_0, '0']
- [lora_sdr_mu_synchro_0, '0', lora_sdr_mu_demod_0, '0']
- [lora_sdr_mu_synchro_0, '0', lora_sdr_partial_ml_0, '0']
- [lora_sdr_mu_synchro_0, '1', blocks_file_sink_1_0_1, '0']
- [lora_sdr_noise_est_0, noise_est, lora_sdr_mu_detection_0, noise_est]
- [lora_sdr_partial_ml_0, '0', blocks_null_sink_0, '0']
- [lora_sdr_partial_ml_0, '1', blocks_file_sink_0, '0']
- [lora_sdr_partial_ml_0, '2', blocks_file_sink_0_0, '0']
- [lora_sdr_signal_detector_0, '0', lora_sdr_mu_detection_0, '0']
- [virtual_source_0, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_0, '0', lora_sdr_signal_detector_0, '0']

metadata:
  file_format: 1
