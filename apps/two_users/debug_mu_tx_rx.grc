<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>debug_mu_tx_rx</value></param>
<param><key>description</key><value>example of a configuration that send and receives frames for BER measurement (here the two USRPs are linked by a MIMO cable)</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RX_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TX_gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>calib_off_u2</value></param>
<param><key>value</key><value>0.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>868e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfo</value></param>
<param><key>value</key><value>[0.0,0.0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>int(0*os_factor_tx*2**sf)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>digital_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>3</value></param>
<param><key>min</key><value>-20</value></param>
<param><key>num_steps</key><value>23</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_frame</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>os_factor_rx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>os_factor_tx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pay_len</value></param>
<param><key>value</key><value>120</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>power</value></param>
<param><key>value</key><value>[-np.inf,digital_gain]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rand_sto</value></param>
<param><key>value</key><value>[False,False]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snr_thres</value></param>
<param><key>value</key><value>-9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sto</value></param>
<param><key>value</key><value>[0.0,0.0]</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>10**(-4.2/20.0)</value></param>
<param><key>comment</key><value>Rough correction of CFO between the Tx and Rx.</value></param>
<param><key>freq</key><value>0*samp_rate/2**sf</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate*os_factor_tx</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_1</value></param>
<param><key>comment</key><value>Delay used to estimate the noise power in the
beginning of transmission</value></param>
<param><key>delay</key><value>2**sf*os_factor_tx*150</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_2</value></param>
<param><key>delay</key><value>int(2**sf*os_factor_tx*150)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/debug/frame_src1_out.txt</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/debug/frame_src2_out.txt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/debug/mu_sync_out.txt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/debug/mu_detect_out.txt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/debug/mu_detect_in.txt</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/measurements/mu_demod_s1.txt</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/measurements/mu_demod_s2.txt</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/measurements/mu_snr.txt</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/measurements/sync_state.txt</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/debug/partial_ml_out_m1.txt</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>2**sf</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/debug/partial_ml_out_m2.txt</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>2**sf</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/measurements/mu_source_s1.txt</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/jtappare/Documents/lora_gnu_radio_prototype/matlab/measurements/mu_source_s2.txt</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>os_factor_rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10**((power[0])/20.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>10**((power[1]+calib_off_u2)/20.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>128</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_2_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>2**sf*os_factor_rx*40</value></param>
<param><key>samples_per_second</key><value>samp_rate*os_factor_tx*100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>np.sqrt(1)</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0/0.9 + 0.0j</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>lora_sdr_frame_src</key>
<param><key>id</key><value>lora_sdr_frame_src_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>cfo</key><value>cfo[0]</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>n_frames</key><value>n_frame</value></param>
<param><key>offset</key><value>int(np.round(sto[0]*os_factor_tx))</value></param>
<param><key>os_factor</key><value>os_factor_tx</value></param>
<param><key>pay_len</key><value>pay_len</value></param>
<param><key>rand_sto</key><value>rand_sto[0]</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_frame_src</key>
<param><key>id</key><value>lora_sdr_frame_src_0_0</value></param>
<param><key>bw</key><value>bw</value></param>
<param><key>cfo</key><value>cfo[1]</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>n_frames</key><value>n_frame</value></param>
<param><key>offset</key><value>int(np.round((15*2**sf+sto[1])*os_factor_tx))</value></param>
<param><key>os_factor</key><value>os_factor_tx</value></param>
<param><key>pay_len</key><value>pay_len</value></param>
<param><key>rand_sto</key><value>rand_sto[1]</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_mu_demod</key>
<param><key>id</key><value>lora_sdr_mu_demod_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>Ki</key><value>2**sf</value></param>
<param><key>Ku</key><value>5</value></param>
<param><key>minoutbuf</key><value>2**sf*200</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_mu_detection</key>
<param><key>id</key><value>lora_sdr_mu_detection_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>2**sf*os_factor_rx*200</value></param>
<param><key>os_factor</key><value>os_factor_rx</value></param>
<param><key>sf</key><value>sf</value></param>
<param><key>snr_threshold</key><value>snr_thres</value></param>
</block>
<block>
<key>lora_sdr_mu_synchro</key>
<param><key>id</key><value>lora_sdr_mu_synchro_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len</key><value>pay_len</value></param>
<param><key>minoutbuf</key><value>2**sf*200</value></param>
<param><key>os_factor</key><value>os_factor_rx</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_noise_est</key>
<param><key>id</key><value>lora_sdr_noise_est_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n_samples</key><value>2**sf*30</value></param>
</block>
<block>
<key>lora_sdr_partial_ml</key>
<param><key>id</key><value>lora_sdr_partial_ml_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>_id</key><value>0</value></param>
<param><key>Ki</key><value>0</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_sdr_signal_detector</key>
<param><key>id</key><value>lora_sdr_signal_detector_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_symb</key><value>4</value></param>
<param><key>margin</key><value>8</value></param>
<param><key>minoutbuf</key><value>2**sf*os_factor_rx*800</value></param>
<param><key>os_factor</key><value>os_factor_rx</value></param>
<param><key>sf</key><value>sf</value></param>
<param><key>threshold</key><value>10</value></param>
<param><key>transp_len</key><value>50</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>TX_gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>bw1</key><value>bw</value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>TX_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.3,addr1=192.168.10.2"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate*os_factor_tx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>bw*os_factor_rx</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>RX_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.4"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>2**sf*os_factor_rx*200</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>bw*os_factor_rx</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_chans</key><value></value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_2</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>lora_sdr_noise_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_delay_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_delay_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>lora_sdr_signal_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_src_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_src_0</source_block_id><sink_block_id>blocks_file_sink_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_src_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_frame_src_0_0</source_block_id><sink_block_id>blocks_file_sink_3_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_demod_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_demod_0</source_block_id><sink_block_id>blocks_null_sink_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_demod_0</source_block_id><sink_block_id>blocks_file_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_demod_0</source_block_id><sink_block_id>blocks_null_sink_0_2_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_demod_0</source_block_id><sink_block_id>blocks_file_sink_1_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_demod_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_detection_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_detection_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_detection_0</source_block_id><sink_block_id>lora_sdr_mu_synchro_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_synchro_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_synchro_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_synchro_0</source_block_id><sink_block_id>lora_sdr_mu_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_synchro_0</source_block_id><sink_block_id>lora_sdr_partial_ml_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_mu_synchro_0</source_block_id><sink_block_id>blocks_file_sink_1_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_noise_est_0</source_block_id><sink_block_id>lora_sdr_mu_detection_0</sink_block_id><source_key>noise_est</source_key><sink_key>noise_est</sink_key></connection>
<connection><source_block_id>lora_sdr_partial_ml_0_2</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_partial_ml_0_2</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_partial_ml_0_2</source_block_id><sink_block_id>blocks_null_sink_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_partial_ml_0_2</source_block_id><sink_block_id>blocks_file_sink_2_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_partial_ml_0_2</source_block_id><sink_block_id>blocks_null_sink_0_2</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lora_sdr_signal_detector_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_sdr_signal_detector_0</source_block_id><sink_block_id>lora_sdr_mu_detection_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lora_sdr_signal_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
